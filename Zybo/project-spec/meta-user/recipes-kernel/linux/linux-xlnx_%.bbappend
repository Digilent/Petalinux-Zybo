SRC_URI += "file://user_2018-01-30-09-36-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

